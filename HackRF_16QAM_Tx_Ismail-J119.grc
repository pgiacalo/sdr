options:
  parameters:
    description: Block diagram from HackRF_16QAM_Ismail-J119.pdf
    generate_options: qt_gui
    id: QAM16_Transmitter
    output_language: python
    title: 16QAM Transmitter
  states: {}

blocks:
- name: Constellation16QAM
  id: variable_constellation
  parameters:
    const_points: '[-3.0-3.0j, -1.0-3.0j, 1.0-3.0j, 3.0-3.0j, -3.0-1.0j, -1.0-1.0j, 1.0-1.0j, 3.0-1.0j, -3.0+1.0j, -1.0+1.0j, 1.0+1.0j, 3.0+1.0j, -3.0+3.0j, -1.0+3.0j, 1.0+3.0j, 3.0+3.0j]'
    precision: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    type: 16qam
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: scale
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/phil/dev/python/sdr/qam_signals.txt
    repeat: 'True'
    type: byte
    vlen: '16'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '8192'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: Constellation16QAM
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: mono_16bps_22k
  id: blocks_wavfile_source
  parameters:
    file: /Users/phil/dev/python/sdr/mono_16bps_22k.wav
    repeat: 'True'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '16'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_3200
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [mono_16bps_22k, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
