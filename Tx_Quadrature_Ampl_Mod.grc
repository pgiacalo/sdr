options:
  parameters:
    description: QAM Transmitter of Audio WAV file
    generate_options: qt_gui
    id: Tx_Quadrature_Ampl_Mod
    output_language: python
    title: Tx QAM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: scale
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /Users/phil/dev/python/sdr/preamble.wav
    repeat: 'True'
  states: {}
- name: digital_qam_mod_0
  id: digital_qam_mod
  parameters:
    constellation_points: '16'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: '20'
    freq0: 4e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: 120e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '100'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Audio Post-Encoding"'
    size: '1024'
    srate: '8000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    type: fff
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_3200
  states: {}

connections:
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_qam_mod_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_0, '0']
- [digital_qam_mod_0, '0', osmosdr_sink_0, '0']
- [digital_qam_mod_0, '0', qtgui_const_sink_x_0, '0']
- [digital_qam_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
